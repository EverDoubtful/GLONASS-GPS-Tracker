# Keil uVision project trackApp.uvproj, settings and files
target Release (ARM-ADS)
  device: STM32F103VG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fmware
  AfterMake: C:\UTRACK\PROJECTS\TRACKER_V2_0\trk_v2_multi\App\MDK-ARM\axf2bin.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,  STM32F10X_XL, USE_STM3210E_EVAL, VER_2
  c include: ..\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\fatFS\src;..\AIS326DQ;..\GSM;..\..\App;..\PERIF\inc;..\fifo;..\NotUsedYet
  memory RVCT4: ROM 0x8008000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../src/: stm32f10x_it.c main.cpp hw_config.c sdcardUser.c alarm.c waveplayer.c
  group USBLibrary
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10xDriver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_dac.c misc.c
  group MDK-ARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../src/: system_stm32f10x.c
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group SD_CARD
    ../PERIF/src/: sdSDIODrv.c
  group Doc
    ../: readme.txt TechnologyCard.txt
  group FatFS
    ../fatfsDrv/: diskio.c
    ../../Libraries/fatFS/src/: ff.c
  group NMEA_LIB
    ../nmea/: context.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group GSM
    ../GSM/: gsm.c
    ../PERIF/src/: ftp.c
  group ACCEL
    ../AIS326DQ/: ais326dq.c
  group PERIF
    ../NotUsedYet/: DAC.c
    ../PERIF/src/: adc.c button.c common.c dio_led.c gps.c i2c1.c rs_485.c spi1.c gprs_modem.c rtc.c packets.c protocol_ascii.c hand_conf.c protocol_bin.c bin_handle.c crc.c menu.c flash.c timers.c
    ../src/: bkp.c
  group FIFO
    ../fifo/: fifo.c fifoPackets.c
  group NotUsedYet
    ../NotUsedYet/: ibutton.c rfmodem.c
  group VCP_MASS_STRG
    ../src/: mass_mal.c memory.c usb_scsi.c usb_pwr.c usb_prop.c usb_endp.c usb_istr.c usb_desc.c usb_bot.c scsi_data.c
