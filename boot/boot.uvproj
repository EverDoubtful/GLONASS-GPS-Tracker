# Keil uVision project boot.uvproj, settings and files
target bootSector (ARM-ADS)
  device: STM32F103VG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bootloader +hex
  AfterMake: FromElf.exe --bin --output Obj\bootloader.bin Obj\bootloader.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL, USE_STM3210E_EVAL, VER_3
  c include: .\Source\App;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --keep abs_address.o(.constdata)
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_xl.s
  group APP
    ./Source/App/: main.c stm32f10x_it.c ftp.c gprs_modem.cpp fifo.c button.c dio_led.c ABS_ADDRESS.c
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Doc
    ./: readme.txt
